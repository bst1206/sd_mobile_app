<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Basic Comms - Coordinator - SAPI.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Basic Comms - Router - AFZDO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Hello World.ewp</path>
  </project>
  <batchBuild/>
</workspace>


