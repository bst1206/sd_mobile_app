<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\Users\Baek\UTD\Courses\11Fall\CE4370\Labs\Lab4\Lab4.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\Users\Baek\UTD\Courses\11Fall\CE4370\Labs\Lab5\Lab5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


