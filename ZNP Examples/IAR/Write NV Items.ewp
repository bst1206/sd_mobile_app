# IAR project Write NV Items.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: ZNP_INTERFACE_VERBOSE=1
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZNP; ../HAL; ../Common
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../: example_write_nv_items.c
    ../../HAL/: hal_cc2530znp_target_board.c
  group Common
    ../../Common/: printf.c utilities.c
  group ZNP
    ../../ZNP/: znp_interface.c znp_interface_spi.c
